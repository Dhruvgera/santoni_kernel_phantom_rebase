## drivers/input/touchscreen/ft5336/Kconfig
```kconfig
config TOUCHSCREEN_FT5336
	default y
	bool "FOCALTECH FT5336 touchpanel driver"
	depends on CONFIG_INPUT_TOUCHSCREEN
```
